# IAR project LPLD_HelloWorld_K60DZ10.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 NXP MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: LPLD_K60; USE_K60DZ10
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPLD_HelloWorld_K60DZ10.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.FPU2: 0
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.FPU2: 0
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DX256_BOOT.icf
  group app
    ../app/: k60_card.h LPLD_HelloWorld.c
  group lib/common
    ../../../lib/common/: alloc.c assert.c assert.h common.h io.c io.h printf.c queue.c queue.h relocate.c relocate.h stdlib.c stdlib.h uif.c uif.h
  group lib/CPU
    ../../../lib/CPU/: startup_K60DZ10.s system_MK60.c
  group lib/LPLD
    ../../../lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/HW
    ../../../lib/LPLD/HW/: HW_ADC.c HW_ADC.h HW_DMA.c HW_DMA.h HW_FTM.c HW_FTM.h HW_GPIO.c HW_GPIO.h HW_MCG.c HW_MCG.h HW_PIT.c HW_PIT.h HW_UART.c HW_UART.h
